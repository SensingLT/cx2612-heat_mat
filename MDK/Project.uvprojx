# Keil uVision project Project.uvprojx, settings and files
target Porject (6220000::V6.22::ARMCLANG)
  device: PT32Y003F4x6 PengpaiMicroelectronics
  pack: PAI-IC.PT32Y003_DFP.1.6.0
  cpu: IRAM(0x20000000,0x0800) IROM(0x00000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Project +hex
  BeforeMake: ..\public\beforeBuild.bat .\Listings
  AfterMake: ..\public\afterBuild.bat .\Listings !L
  c flags: Optim=7 oTime=1 OneElfS=1 v6Lang=5 v6LangP=3 v6Lto=1 wLevel=3
  c define: USE_STDPERIPH_DRIVER,USE_FULL_ASSERT
  c include: ..\Libraries\PT32Y003x_FWLib\inc;..\Libraries\SYSTEM;..\Libraries\CMSIS;..\driver;..\RTT;..\MDK;..\public\inc;..\..\CX2504-MotorBike-115200
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x800
  group driver
    ../driver/: adc.c adc.h uart.c uart.h wdg.c wdg.h
  group User
    ../: main.c PT32Y003x_it.c system_PT32Y003x.c tick.c tick.h base.h crc.c crc.h config.h
  group System
    ../Libraries/SYSTEM/: startup_PT32Y003x.s
  group Retarget
    ../Libraries/Retarget/: PT32Y003x_retarget.c
  group PT32Y003x_FWLib
    ../Libraries/PT32Y003x_FWLib/src/: PT32Y003x_adc.c PT32Y003x_crc.c PT32Y003x_exti.c PT32Y003x_gpio.c PT32Y003x_i2c.c PT32Y003x_id.c PT32Y003x_immc.c PT32Y003x_pwm.c PT32Y003x_pwr.c PT32Y003x_rcc.c PT32Y003x_spi.c PT32Y003x_tim.c PT32Y003x_uart.c PT32Y003x_wdg.c PT32Y003x_nvic.c
software components: CMSIS:CORE 5.4.0
